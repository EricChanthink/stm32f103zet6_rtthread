# Keil uVision project RTT_F103ZE.uvprojx, settings and files
target RT-Thread_STM32F103ZE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTT_F103ZE +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\bsp\drivers;.\bsp\Libraries\CMSIS\CM3\CoreSupport;.\components\init;.\components\finsh;.\DeviceDrivers\drivers\include;.\RT_Thread-2.0.1\include;.\bsp\Libraries\STM32F10x_StdPeriph_Driver\inc;.\RT_Thread-2.0.1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group application
    ./application/: application.c startup.c
  group bsp
    ./bsp/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./bsp/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./bsp/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./bsp/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ./bsp/drivers/: stm32f10x_it.c stm32f10x_it.h
  group components
    ./components/init/: components.c
  group DeviceDrivers
    ./DeviceDrivers/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ./DeviceDrivers/drivers/serial/: serial.c
  group context-m3
    ./libcup/common/: backtrace.c div0.c showmem.c
    ./libcup/cortex-m3/: cpuport.c context_rvds.S
  group RT-Thread-2.0.1
    ./RT_Thread-2.0.1/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group finsh
    ./components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group Drivers
    ./bsp/drivers/: board.c led.c usart.c
